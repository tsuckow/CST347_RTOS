# Keil uVision project Lab2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Lab2 +hex
  c flags: Optim=1
  c include: SROS/source, .
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group SROS
    ./SROS/source/: mailboxObjectAsm.s mutexObjectAsm.s rtos.c rtos.h rtosAsm.h rtosAsm.s semaphoreObjectAsm.s typeDef.h
  group ?
    ./SROS/armTestBench/: testSemaphoreObject.c sampleInterruptServiceRoutine.c
  group Serial
    ./serial/: Retarget.c Serial.c
  group LCD
    ./lcd/: LCD_4bit.c LCD.h
  group LED
    ./LED/: led.c
  group Timer
    ./: timer.c timer.h
